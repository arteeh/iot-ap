# Keil uVision project usart.uvprojx, settings and files
target usart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./src/: main.c mainsystick.c mainfordebug.c usart.c stm32f0xx_it.c include.c
    ./inc/: include.h
  group startup
    ./startup/: startup_stm32f0xx.s system_stm32f0xx.c
target systick (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: as above
  output: usart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: as above
  output: usart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000

# Keil uVision project testproj.uvprojx, settings and files
target testproj (ARM-ADS)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: testproj
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ./src/: main.c
    ./inc/: main.h
software components: CMSIS:CORE 5.1.1, Device:STM32Cube LL:COMMON 1.11.0, Device:STM32Cube LL:COMP 1.11.0, Device:STM32Cube LL:CRC 1.11.0, Device:STM32Cube LL:CRS 1.11.0, Device:STM32Cube LL:DAC 1.11.0, Device:STM32Cube LL:DMA 1.11.0, Device:STM32Cube LL:EXTI 1.11.0, Device:STM32Cube LL:GPIO 1.11.0, Device:STM32Cube LL:I2C 1.11.0, Device:STM32Cube LL:PWR 1.11.0, Device:STM32Cube LL:RCC 1.11.0, Device:STM32Cube LL:RTC 1.11.0, Device:STM32Cube LL:SPI 1.11.0, Device:STM32Cube LL:TIM 1.11.0, Device:STM32Cube LL:USART 1.11.0, Device:STM32Cube LL:USB 1.11.0, Device:STM32Cube LL:UTILS 1.11.0, Device:Startup 1.0.0
